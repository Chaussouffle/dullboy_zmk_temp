## config/boards/shields/dullboy36c/Kconfig.shield
```kconfig
config SHIELD_DULLBOY
    bool "dullboy (monobloc 4x10, 36 keys)"
    select ZMK_KEYBOARD_CUSTOM
```
